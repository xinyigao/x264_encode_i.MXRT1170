# IAR project sdcard_fatfs_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; MIMXRT1176/iar; component/lists; component/osa; component/serial_manager; component/uart; device; doc; drivers; evkmimxrt1170; fatfs/source; fatfs/source/fsl_sd_disk; sdmmc/host; sdmmc/inc; sdmmc/osa; startup; utilities; xip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: sdcard_fatfs_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x800
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NXP_RT1176_cm7 NXP RT1176_cm7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: sdcard_fatfs_cm7.srec
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NXP_RT1176_cm7 NXP RT1176_cm7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NXP_RT1176_cm7 NXP RT1176_cm7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NXP_RT1176_cm7 NXP RT1176_cm7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    component/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/serial_manager
    component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_anatop.c fsl_anatop.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dcdc.c fsl_dcdc.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pmu.c fsl_pmu.h fsl_usdhc.c fsl_usdhc.h
  group evkmimxrt1170
    evkmimxrt1170/: evkmimxrt1170_connect_cm7.mac
  group fatfs/source
    fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group MIMXRT1176/iar
    MIMXRT1176/iar/: MIMXRT1176xxxxx_cm7_ram.icf
  group sdmmc
    sdmmc/: ChangeLogKSDK.txt
  group sdmmc/host
    sdmmc/host/: ChangeLogKSDK.txt fsl_sdmmc_host.c fsl_sdmmc_host.h
  group sdmmc/inc
    sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/osa
    sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group sdmmc/src
    sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    source/: ffconf.h sdcard_fatfs.c
  group startup
    startup/: startup_MIMXRT1176_cm7.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group xip
    xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
