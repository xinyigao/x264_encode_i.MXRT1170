# IAR project cmsis_lpspi_edma_b2b_transfer_master_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: NXP_RT1176_cm4 NXP RT1176_cm4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../..; ..; ../../../../../../../../CMSIS/Driver/Include; ../../../../../..; ../../../../../../../../CMSIS/Include; ../../../../../../../../devices; ../../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../../devices/MIMXRT1176/cmsis_drivers; ../../../../../../../../devices/MIMXRT1176; ../../../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../../../components/uart; ../../../../../../../../components/serial_manager; ../../../../../../../../components/lists; ../../../../../../../../devices/MIMXRT1176/xip; ../../../../../../xip; ../../../../../../../../devices/MIMXRT1176/drivers/cm4; ../../../../../../../../devices/MIMXRT1176/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_lpspi_edma_b2b_transfer_master_cm4.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; CPU_MIMXRT1176DVMAA_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; CPU_MIMXRT1176DVMAA_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_sdram.icf
  group source
    ../: cmsis_lpspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_common.h fsl_common.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_anatop.h fsl_anatop.c
    ../../../../../../../../devices/MIMXRT1176/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
    ../../../../../../../../devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group CMSIS
    ../../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group utilities
    ../../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
  group xip
    ../../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS_driver
    ../../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
